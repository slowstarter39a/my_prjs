
EXTRA_OECONF:append = " --enable-tui "
